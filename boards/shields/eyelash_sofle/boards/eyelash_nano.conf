## boards/shields/prospector_nice_nano/Kconfig.shield
```kconfig
config SHIELD_PROSPECTOR_NICE_NANO
    def_bool $(shields_list_contains,prospector_nice_nano)
```
